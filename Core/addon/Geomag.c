/* PROGRAM MAGPOINT (GEOMAG DRIVER) */

#include <math.h>
#include <stdio.h>
#include <string.h>

/* 	Ker program v prvotni verziji bere iz www-95.dat, se file
	zamenja z *fmodel[], funkcije fgets pa z strcpy !!
*/
struct f	{
			int 	a,b;
			float	f1,f2,f3,f4;
			}	fmodel[]=
{
{  1,  0,  -29616.0,       0.0,       14.7,        0.0},
{  1,  1,   -1722.7,    5194.5,       11.1,      -20.4},
{  2,  0,   -2266.7,       0.0,      -13.6,        0.0},
{  2,  1,    3070.2,   -2484.8,       -0.7,      -21.5},
{  2,  2,    1677.6,    -467.9,       -1.8,       -9.6},
{  3,  0,    1322.4,       0.0,        0.3,        0.0},
{  3,  1,   -2291.5,    -224.7,       -4.3,        6.4},
{  3,  2,    1255.9,     293.0,        0.9,       -1.3},
{  3,  3,     724.8,    -486.5,       -8.4,      -13.3},
{  4,  0,     932.1,       0.0,       -1.6,        0.0},
{  4,  1,     786.3,     273.3,        0.9,        2.3},
{  4,  2,     250.6,    -227.9,       -7.6,        0.7},
{  4,  3,    -401.5,     120.9,        2.2,        3.7},
{  4,  4,     106.2,    -302.7,       -3.2,       -0.5},
{  5,  0,    -211.9,       0.0,       -0.9,        0.0},
{  5,  1,     351.6,      42.0,       -0.2,        0.0},
{  5,  2,     220.8,     173.8,       -2.5,        2.1},
{  5,  3,    -134.5,    -135.0,       -2.7,        2.3},
{  5,  4,    -168.8,     -38.6,       -0.9,        3.1},
{  5,  5,     -13.3,     105.2,        1.7,        0.0},
{  6,  0,      73.8,       0.0,        1.2,        0.0},
{  6,  1,      68.2,     -17.4,        0.2,       -0.3},
{  6,  2,      74.1,      61.2,        1.7,       -1.7},
{  6,  3,    -163.5,      63.2,        1.6,       -0.9},
{  6,  4,      -3.8,     -62.9,       -0.1,       -1.0},
{  6,  5,      17.1,       0.2,       -0.3,       -0.1},
{  6,  6,     -85.1,      43.0,        0.8,        1.9},
{  7,  0,      77.4,       0.0,       -0.4,        0.0},
{  7,  1,     -73.9,     -62.3,       -0.8,        1.4},
{  7,  2,       2.2,     -24.5,       -0.2,        0.2},
{  7,  3,      35.7,       8.9,        1.1,        0.7},
{  7,  4,       7.3,      23.4,        0.4,        0.4},
{  7,  5,       5.2,      15.0,        0.0,       -0.3},
{  7,  6,       8.4,     -27.6,       -0.2,       -0.8},
{  7,  7,      -1.5,      -7.8,       -0.2,       -0.1},
{  8,  0,      23.3,       0.0,       -0.3,        0.0},
{  8,  1,       7.3,      12.4,        0.6,       -0.5},
{  8,  2,      -8.5,     -20.8,       -0.8,        0.1},
{  8,  3,      -6.6,       8.4,        0.3,       -0.2},
{  8,  4,     -16.9,     -21.2,       -0.2,        0.0},
{  8,  5,       8.6,      15.5,        0.5,        0.1},
{  8,  6,       4.9,       9.1,        0.0,       -0.1},
{  8,  7,      -7.8,     -15.5,       -0.6,        0.3},
{  8,  8,      -7.6,      -5.4,        0.1,        0.2},
{  9,  0,       5.7,       0.0,        0.0,        0.0},
{  9,  1,       8.5,     -20.4,        0.0,        0.0},
{  9,  2,       2.0,      13.9,        0.0,        0.0},
{  9,  3,      -9.8,      12.0,        0.0,        0.0},
{  9,  4,       7.6,      -6.2,        0.0,        0.0},
{  9,  5,      -7.0,      -8.6,        0.0,        0.0},
{  9,  6,      -2.0,       9.4,        0.0,        0.0},
{  9,  7,       9.2,       5.0,        0.0,        0.0},
{  9,  8,      -2.2,      -8.4,        0.0,        0.0},
{  9,  9,      -6.6,       3.2,        0.0,        0.0},
{ 10,  0,      -2.2,       0.0,        0.0,        0.0},
{ 10,  1,      -5.7,       0.9,        0.0,        0.0},
{ 10,  2,       1.6,      -0.7,        0.0,        0.0},
{ 10,  3,      -3.7,       3.9,        0.0,        0.0},
{ 10,  4,      -0.6,       4.8,        0.0,        0.0},
{ 10,  5,       4.1,      -5.3,        0.0,        0.0},
{ 10,  6,       2.2,      -1.0,        0.0,        0.0},
{ 10,  7,       2.2,      -2.4,        0.0,        0.0},
{ 10,  8,       4.6,       1.3,        0.0,        0.0},
{ 10,  9,       2.3,      -2.3,        0.0,        0.0},
{ 10, 10,       0.1,      -6.4,        0.0,        0.0},
{ 11,  0,       3.3,       0.0,        0.0,        0.0},
{ 11,  1,      -1.1,      -1.5,        0.0,        0.0},
{ 11,  2,      -2.4,       0.7,        0.0,        0.0},
{ 11,  3,       2.6,      -1.1,        0.0,        0.0},
{ 11,  4,      -1.3,      -2.3,        0.0,        0.0},
{ 11,  5,      -1.7,       1.3,        0.0,        0.0},
{ 11,  6,      -0.6,      -0.6,        0.0,        0.0},
{ 11,  7,       0.4,      -2.8,        0.0,        0.0},
{ 11,  8,       0.7,      -1.6,        0.0,        0.0},
{ 11,  9,      -0.3,      -0.1,        0.0,        0.0},
{ 11, 10,       2.3,      -1.9,        0.0,        0.0},
{ 11, 11,       4.2,       1.4,        0.0,        0.0},
{ 12,  0,      -1.5,       0.0,        0.0,        0.0},
{ 12,  1,      -0.2,      -1.0,        0.0,        0.0},
{ 12,  2,      -0.3,       0.7,        0.0,        0.0},
{ 12,  3,       0.5,       2.2,        0.0,        0.0},
{ 12,  4,       0.2,      -2.5,        0.0,        0.0},
{ 12,  5,       0.9,      -0.2,        0.0,        0.0},
{ 12,  6,      -1.4,       0.0,        0.0,        0.0},
{ 12,  7,       0.6,      -0.2,        0.0,        0.0},
{ 12,  8,      -0.6,       0.0,        0.0,        0.0},
{ 12,  9,      -1.0,       0.2,        0.0,        0.0},
{ 12, 10,      -0.3,      -0.9,        0.0,        0.0},
{ 12, 11,       0.3,      -0.2,        0.0,        0.0},
{ 12, 12,       0.4,       1.0,        0.0,        0.0},
{  0,  0,       0.0,       0.0,        0.0,        0.0}};
/*
{1,0,-29682.1,0.0,17.6,0.0},
{1,1,-1782.2,5315.6,13.2,-18.0},
{2,0,-2194.7,0.0,-13.7,0.0},
{2,1,3078.6,-2359.1,4.0,-14.6},
{2,2,1685.7,-418.6,-0.3,-7.2},
{3,0,1318.8,0.0,0.8,0.0},
{3,1,-2273.6,-261.1,-6.6,4.0},
{3,2,1246.9,301.0,-0.5,2.2},
{3,3,766.3,-416.5,-8.5,-12.6},
{4,0,940.0,0.0,1.2,0.0},
{4,1,782.9,259.4,1.1,1.3},
{4,2,290.9,-230.9,-6.8,1.0},
{4,3,-418.9,99.8,0.3,2.5},
{4,4,113.8,-306.1,-4.5,-1.2},
{5,0,-209.5,0.0,0.9,0.0},
{5,1,354.0,43.7,0.5,0.5},
{5,2,238.2,157.6,-1.4,1.5},
{5,3,-122.1,-150.1,-1.7,0.6},
{5,4,-162.8,-59.2,0.0,1.7},
{5,5,-23.3,104.4,2.1,0.6},
{6,0,68.5,0.0,0.4,0.0},
{6,1,65.6,-15.2,-0.3,0.7},
{6,2,64.1,74.3,0.3,-1.5},
{6,3,-169.1,69.4,2.1,-0.5},
{6,4,-0.5,-55.3,0.0,-0.7},
{6,5,16.5,3.0,-0.4,1.1},
{6,6,-91.0,33.3,-0.4,2.6},
{7,0,78.0,0.0,-0.3,0.0},
{7,1,-68.1,-76.1,-1.1,0.3},
{7,2,0.1,-24.5,-0.5,0.0},
{7,3,29.6,1.6,0.5,0.7},
{7,4,6.0,20.0,1.3,-0.6},
{7,5,8.7,16.5,0.1,0.1},
{7,6,9.2,-23.6,0.0,-0.6},
{7,7,-2.4,-6.8,-0.9,-0.4},
{8,0,24.7,0.0,0.1,0.0},
{8,1,3.4,14.9,0.0,0.4},
{8,2,-1.5,-19.5,0.4,-0.3},
{8,3,-9.6,6.3,0.3,0.1},
{8,4,-16.5,-20.4,-1.3,0.8},
{8,5,2.6,12.2,0.5,-0.1},
{8,6,3.6,7.0,0.4,-1.3},
{8,7,-4.9,-19.0,-0.9,-0.9},
{8,8,-8.5,-8.8,0.1,-1.1},
{9,0,2.9,0.0,0.0,0.0},
{9,1,7.5,-19.8,0.0,0.0},
{9,2,0.4,14.6,0.0,0.0},
{9,3,-10.3,10.9,0.0,0.0},
{9,4,9.7,-7.5,0.0,0.0},
{9,5,-2.3,-6.8,0.0,0.0},
{9,6,-2.4,9.3,0.0,0.0},
{9,7,6.8,7.7,0.0,0.0},
{9,8,-0.5,-8.1,0.0,0.0},
{9,9,-6.5,2.6,0.0,0.0},
{10,0,-2.9,0.0,0.0,0.0},
{10,1,-3.3,3.2,0.0,0.0},
{10,2,2.8,1.7,0.0,0.0},
{10,3,-4.3,2.9,0.0,0.0},
{10,4,-3.1,5.6,0.0,0.0},
{10,5,2.4,-3.4,0.0,0.0},
{10,6,2.8,-0.7,0.0,0.0},
{10,7,0.7,-2.9,0.0,0.0},
{10,8,4.1,2.3,0.0,0.0},
{10,9,3.6,-1.6,0.0,0.0},
{10,10,0.6,-6.6,0.0,0.0},
{11,0,1.7,0.0,0.0,0.0},
{11,1,-1.6,0.3,0.0,0.0},
{11,2,-3.6,1.0,0.0,0.0},
{11,3,1.2,-3.6,0.0,0.0},
{11,4,-0.6,-1.4,0.0,0.0},
{11,5,0.1,1.9,0.0,0.0},
{11,6,-0.7,0.2,0.0,0.0},
{11,7,-0.8,-1.3,0.0,0.0},
{11,8,1.3,-2.4,0.0,0.0},
{11,9,-0.3,-0.6,0.0,0.0},
{11,10,2.2,-2.2,0.0,0.0},
{11,11,4.2,1.3,0.0,0.0},
{12,0,-1.8,0.0,0.0,0.0},
{12,1,0.9,0.3,0.0,0.0},
{12,2,-0.1,1.4,0.0,0.0},
{12,3,-0.5,0.8,0.0,0.0},
{12,4,0.8,-3.0,0.0,0.0},
{12,5,0.2,0.7,0.0,0.0},
{12,6,0.5,0.5,0.0,0.0},
{12,7,0.4,-0.8,0.0,0.0},
{12,8,-0.4,0.6,0.0,0.0},
{12,9,0.3,0.1,0.0,0.0},
{12,10,0.2,-1.3,0.0,0.0},
{12,11,0.4,-0.4,0.0,0.0},
{12,12,0.6,0.9,0.0,0.0},
{0,0,0.0,0.0,0.0,0.0},
};
*/

float	MainFld(float dlat,float dlon, float altm, float time)
		{
void E0000(int,int *,float,float,float,float,
				float *,float *,float *,float *);
		float 	dec, dip, ti, gv;
		int	 	maxdeg=12;

/* INITIALIZE GEOMAG ROUTINE */

		E0000(0,&maxdeg,0.0,0.0,0.0,0.0,NULL,NULL,NULL,NULL);
		E0000(1,NULL,altm,dlat,dlon,time,&dec,&dip,&ti,&gv);
		return(dec * 60.0);
}
/*************************************************************************/
void E0000(int IENTRY,int *maxdeg,float alt,float glat,float glon, float time,
				float *dec,float *dip,float *ti,float *gv)
{
	 static int maxord,n,m,j,D1,D2,D3,D4;
	 static float c[13][13],cd[13][13],tc[13][13],dp[13][13],snorm[169],
		  sp[13],cp[13],fn[13],fm[13],pp[13],k[13][13],pi,dtr,a,b,re,
		  a2,b2,c2,a4,b4,c4,epoch,gnm,hnm,dgnm,dhnm,flnmj,otime,oalt,
		  olat,olon,dt,rlon,rlat,srlon,srlat,crlon,crlat,srlat2,
		  crlat2,q,q1,q2,ct,st,r2,r,d,ca,sa,aor,ar,br,bt,bp,bpp,
		  par,temp1,temp2,parp,bx,by,bz,bh;
	 static float *p = snorm;

	 struct f *wmmdat=fmodel;
	 switch(IENTRY){case 0: goto GEOMAG; case 1: goto GEOMG1;}

GEOMAG:
/* INITIALIZE CONSTANTS */
	  maxord = *maxdeg;
	  sp[0] = 0.0;
	  cp[0] = *p = pp[0] = 1.0;
	  dp[0][0] = 0.0;
	  a = 6378.137;
	  b = 6356.7523142;
	  re = 6371.2;
	  a2 = a*a;
	  b2 = b*b;
	  c2 = a2-b2;
	  a4 = a2*a2;
	  b4 = b2*b2;
	  c4 = a4 - b4;

/* READ WORLD MAGNETIC MODEL SPHERICAL HARMONIC COEFFICIENTS */
	  c[0][0] = 0.0;
	  cd[0][0] = 0.0;
	  epoch=2000.0;

while(wmmdat->a) {
	  n=wmmdat->a;
	  m=wmmdat->b;
	  gnm=wmmdat->f1;
	  hnm=wmmdat->f2;
	  dgnm=wmmdat->f3;
	  dhnm=wmmdat->f4;
	  ++ wmmdat;

	  if (m <= n)
	  {
		c[m][n] = gnm;
		cd[m][n] = dgnm;
		if (m != 0)
		{
		  c[n][m-1] = hnm;
		  cd[n][m-1] = dhnm;
		}
	  }
	  }

/* CONVERT SCHMIDT NORMALIZED GAUSS COEFFICIENTS TO UNNORMALIZED */

	  *snorm = 1.0;
	  for (n=1; n<=maxord; n++)
	  {
		*(snorm+n) = *(snorm+n-1)*(float)(2*n-1)/(float)n;
		j = 2;
		for (m=0,D1=1,D2=(n-m+D1)/D1; D2>0; D2--,m+=D1)
		{
		  k[m][n] = (float)(((n-1)*(n-1))-(m*m))/(float)((2*n-1)*(2*n-3));
		  if (m > 0)
		  {
			flnmj = (float)((n-m+1)*j)/(float)(n+m);
			*(snorm+n+m*13) = *(snorm+n+(m-1)*13)*sqrt(flnmj);
			j = 1;
			c[n][m-1] = *(snorm+n+m*13)*c[n][m-1];
			cd[n][m-1] = *(snorm+n+m*13)*cd[n][m-1];
		  }
		  c[m][n] = *(snorm+n+m*13)*c[m][n];
		  cd[m][n] = *(snorm+n+m*13)*cd[m][n];
		}
		fn[n] = (float)(n+1);
		fm[n] = (float)n;
	  }
	  k[1][1] = 0.0;

	  otime = oalt = olat = olon = -1000.0;
	  return;
/*************************************************************************/

GEOMG1:

	  dt = time - epoch;
	  pi = 3.14159265359;
	  dtr = pi/180.0;
	  rlon = glon*dtr;
	  rlat = glat*dtr;
	  srlon = sin(rlon);
	  srlat = sin(rlat);
	  crlon = cos(rlon);
	  crlat = cos(rlat);
	  srlat2 = srlat*srlat;
	  crlat2 = crlat*crlat;
	  sp[1] = srlon;
	  cp[1] = crlon;
	  alt = alt/1000;

/* CONVERT FROM GEODETIC COORDS. TO SPHERICAL COORDS. */
	  if (alt != oalt || glat != olat)
	  {
		q = sqrt(a2-c2*srlat2);
		q1 = alt*q;
		q2 = ((q1+a2)/(q1+b2))*((q1+a2)/(q1+b2));
		ct = srlat/sqrt(q2*crlat2+srlat2);
		st = sqrt(1.0-(ct*ct));
		r2 = (alt*alt)+2.0*q1+(a4-c4*srlat2)/(q*q);
		r = sqrt(r2);
		d = sqrt(a2*crlat2+b2*srlat2);
		ca = (alt+d)/r;
		sa = c2*crlat*srlat/(r*d);
	  }
	  if (glon != olon)
	  {
		for (m=2; m<=maxord; m++)
		{
		  sp[m] = sp[1]*cp[m-1]+cp[1]*sp[m-1];
		  cp[m] = cp[1]*cp[m-1]-sp[1]*sp[m-1];
		}
	  }
	  aor = re/r;
	  ar = aor*aor;
	  br = bt = bp = bpp = 0.0;
	  for (n=1; n<=maxord; n++)
	  {
		ar = ar*aor;
		for (m=0,D3=1,D4=(n+m+D3)/D3; D4>0; D4--,m+=D3)
		{
/*
   COMPUTE UNNORMALIZED ASSOCIATED LEGENDRE POLYNOMIALS
   AND DERIVATIVES VIA RECURSION RELATIONS
*/
		  if (alt != oalt || glat != olat)
		  {
			if (n == m)
            {
              *(p+n+m*13) = st**(p+n-1+(m-1)*13);
              dp[m][n] = st*dp[m-1][n-1]+ct**(p+n-1+(m-1)*13);
              goto S50;
            }
            if (n == 1 && m == 0) 
            {
              *(p+n+m*13) = ct**(p+n-1+m*13);
              dp[m][n] = ct*dp[m][n-1]-st**(p+n-1+m*13);
			  goto S50;
            }
            if (n > 1 && n != m) 
            {
              if (m > n-2) *(p+n-2+m*13) = 0.0;
              if (m > n-2) dp[m][n-2] = 0.0;
              *(p+n+m*13) = ct**(p+n-1+m*13)-k[m][n]**(p+n-2+m*13);
              dp[m][n] = ct*dp[m][n-1] - st**(p+n-1+m*13)-k[m][n]*dp[m][n-2];
             }
		  }
S50:
/*
    TIME ADJUST THE GAUSS COEFFICIENTS
*/
          if (time != otime) 
          {
            tc[m][n] = c[m][n]+dt*cd[m][n];
            if (m != 0) tc[n][m-1] = c[n][m-1]+dt*cd[n][m-1];
          }
/*
	ACCUMULATE TERMS OF THE SPHERICAL HARMONIC EXPANSIONS
*/
          par = ar**(p+n+m*13);
          if (m == 0) 
          {
            temp1 = tc[m][n]*cp[m];
            temp2 = tc[m][n]*sp[m];
          }
          else 
		  {
			temp1 = tc[m][n]*cp[m]+tc[n][m-1]*sp[m];
            temp2 = tc[m][n]*sp[m]-tc[n][m-1]*cp[m];
          }
          bt = bt-ar*temp1*dp[m][n];
          bp += (fm[m]*temp2*par);
          br += (fn[n]*temp1*par);
/*
    SPECIAL CASE:  NORTH/SOUTH GEOGRAPHIC POLES
*/
          if (st == 0.0 && m == 1) 
		  {
            if (n == 1) pp[n] = pp[n-1];
            else pp[n] = ct*pp[n-1]-k[m][n]*pp[n-2];
            parp = ar*pp[n];
            bpp += (fm[m]*temp2*parp);
          }
        }
      }
      if (st == 0.0) bp = bpp;
	  else bp /= st;
/*
    ROTATE MAGNETIC VECTOR COMPONENTS FROM SPHERICAL TO
    GEODETIC COORDINATES
*/
	  bx = -bt*ca-br*sa;
	  by = bp;
	  bz = bt*sa-br*ca;
/*
	COMPUTE DECLINATION (DEC), INCLINATION (DIP) AND
	TOTAL INTENSITY (TI)
*/
	  bh = sqrt((bx*bx)+(by*by));
	  *ti = sqrt((bh*bh)+(bz*bz));
	  *dec = atan2(by,bx)/dtr;
	  *dip = atan2(bz,bh)/dtr;
/*
	COMPUTE MAGNETIC GRID VARIATION IF THE CURRENT
	GEODETIC POSITION IS IN THE ARCTIC OR ANTARCTIC
	(I.E. GLAT > +55 DEGREES OR GLAT < -55 DEGREES)

	OTHERWISE, SET MAGNETIC GRID VARIATION TO -999.0
*/
	  *gv = -999.0;
	  if (fabs(glat) >= 55.)
	  {
		if (glat > 0.0 && glon >= 0.0) *gv = *dec-glon;
		if (glat > 0.0 && glon < 0.0) *gv = *dec+fabs(glon);
		if (glat < 0.0 && glon >= 0.0) *gv = *dec+glon;
		if (glat < 0.0 && glon < 0.0) *gv = *dec-fabs(glon);
		if (*gv > +180.0) *gv -= 360.0;
		if (*gv < -180.0) *gv += 360.0;
	  }
	  otime = time;
	  oalt = alt;
	  olat = glat;
	  olon = glon;
	  return;
}

/*************************************************************************/


